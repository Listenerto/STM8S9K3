# IAR project stm8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S903
  ICCSTM8.CCIncludePath2: E:\cubmax\MyProject\STM8\text2\code\USER; E:\cubmax\MyProject\STM8\text2\code\Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Driver
    Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim5.c
  group User
    USER/: key.c led.c main.c projob.c Show595.c stm8s_conf.h time.c
